.subckt layout_POR VDD VSS
.ends
.end
